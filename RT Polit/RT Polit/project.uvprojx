# Keil uVision project project.uvprojx, settings and files
target RT-Thread IMXRT1052 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread-imxrt +hex
  AfterMake: fromelf --bin !L --output rtthread-mdk.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RT_USING_ARM_LIBC, EVK_MCIMXRM, SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, __FPU_PRESENT = 1,ARM_MATH_CM7,__CC_ARM,
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186 --gnu
  c include: applications;.;aq_drivers;.;aq_hilsim\include;aq_math;.;aq_mavlink\include\autoquad;aq_mavlink\include;aq_mavlink\include\common;aq_mavlink;aq_radio;.;aq_src;.;aq_targets;.;drivers;dspLib;Libraries;Libraries\drivers;Libraries\utilities;Libraries\CMSIS\Include;rt-thread\include;rt-thread\libcpu\arm\cortex-m7;rt-thread\libcpu\arm\common;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Libraries\arm\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: cpuusage.c device_test.c main.c mem_dump.c mem_test.c
  group AQ_drivers
    aq_drivers/: adc.c analog.c aq_serial.c digital.c flash.c hmc5983.c icm20602.c pwm.c rtc.c spl06.c ublox.c
  group AQ_math
    aq_math/: algebra.c rotations.c srcdkf.c
  group AQ_mavlink
    aq_mavlink/: aq_mavlink.c
  group AQ_radio
    aq_radio/: futaba.c mlinkrx.c ppm.c radio.c
  group AQ_src
    aq_src/: LowPassFilterFloat.c alt_ukf.c aq_timer.c calib.c comm.c command.c compass.c config.c control.c d_imu.c fuzzyPID.c geo_mag_declination.c gps.c imu.c motors.c nav.c nav_ukf.c pid.c rc.c run.c signaling.c supervisor.c telemetry.c util.c
  group Drivers
    drivers/: board.c drv_uart.c drv_cache.c platform.c drv_sdram.c drv_pin.c drv_rtc.c drv_spi_bus.c drv_i2c.c drv_sdio.c
  group dsplib
    dspLib/: arm_cortexM7lfdp_math.lib
  group Libraries
    Libraries/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
    Libraries/: system_MIMXRT1052.c
    Libraries/arm/: startup_MIMXRT1052.s
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M7
    rt-thread/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
software components: CMSIS:CORE 5.1.1
